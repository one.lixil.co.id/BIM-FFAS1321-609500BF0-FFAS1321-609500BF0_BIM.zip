Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2021-05-11T10:35:41
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort (4)
Pset_DistributionPortPipe - ConnectionType: WELDED
MEPPortPipe - ProfileShape: ROUND; OuterDiameter: 15 mm; ConnectorDiameter: 15 mm; NominalWidth: 15 mm; NominalHeight: 15 mm
Name | FlowDirection | PortNumber
 | SINK | 1
 | SOURCE | 2
 | SOURCE | 3
 | SINK | 4

# IfcEnergyConversionDevice: Acacia Evolution Concealed Bath & Shower Mixer with U-box, FFAS1321-609500BF0:Acacia Evolution Concealed Bath & Shower Mixer with U-box:3531
In: Level 1
Pset_ManufacturerTypeInformation - ModelReference: Acacia Evolution Concealed Bath & Shower Mixer with U-box; Manufacturer: American Standard; ProductionYear: 2021
Pset_DistributionFlowElementCommon - Reference: Acacia Evolution Concealed Bath & Shower Mixer with U-box
Constraints - Elevation: 0 mm
Dimensions - Area: 0.0782501 m2; Volume: 0.00180708 m3
Identity Data - Mark: 1
Mechanical - System Classification: Domestic Cold Water,Domestic Hot Water
Other - AssetIdentifier: n/a; BarCode: Please Record On Commissioning.; Category: Plumbing Fixtures; Family: FFAS1321-609500BF0: Acacia Evolution Concealed Bath & Shower Mixer with U-box; Family and Type: FFAS1321-609500BF0: Acacia Evolution Concealed Bath & Shower Mixer with U-box; InstallationDate: Please Record On Commissioning.; SerialNumber: Please Record On Commissioning.; Type: FFAS1321-609500BF0: Acacia Evolution Concealed Bath & Shower Mixer with U-box; Type Id: FFAS1321-609500BF0: Acacia Evolution Concealed Bath & Shower Mixer with U-box; WarrantyStartDate: Please Record On Commissioning.
Phasing - Phase Created: New Construction
Constraints(Type) - Default Elevation: 0 mm
Data(Type) - ConnectionSize: n/a; FlowRate: Without Spout: 13.32, Without Shower: 13.92; InstallationType: Wall Mount; ProductCategory: Bathroom Fittings (40); ProductGroup: Bath&Shower Mixer (02); ProductWeight: 2.03 kg; StyleSegment: Modern; SubCategory: Bathroom Faucets (Mixer) (41)
Identity Data(Type) - Assembly Code: C1030200; Description: Acacia Evolution Concealed Bath & Shower Mixer with U-box; Keynote: N13; Manufacturer: American Standard; Model: Acacia Evolution Concealed Bath & Shower Mixer with U-box; OmniClass Number: 23.45.05.14.21.11; OmniClass Title: Bath/Shower Units; Type Comments: FFAS1321-609500BF0; Type Name: Acacia Evolution Concealed Bath & Shower Mixer with U-box; URL: https://www.americanstandard-apac.com/
Model Properties(Type) - _AuthorizedBy: bimstore; _BimSpecGuid: 0; _BSBibleVersion: 16; _CreatedBy: https://www.bimstore.co; _CurrentRevision: 1; _DistributedBy: https://www.bimstore.co; _ObjectUserGuide: https://www.bimstore.co/products/ffas1321-609500bf0/document/object-user-guide; BIMObjectName: AmericanStandard_BathAndShowerMixer_AcaciaE_(FFAS1321-609500BF0); NBSDescription: Shower fittings package; NBSNote: n/a; NBSObjectName: American Standard - Shower fittings package; NBSOfficeMasterTag: n/a; NBSReference: 45-35-70/330
Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; ClassificationName: Uniclass2015; ClassificationValue: Pr_40_20_87_75; CodePerformance: n/a; Color: Chrome; Constituents: n/a; CreatedBy: https://www.americanstandard-apac.com/; CreatedOn: 2021-03-01T09:00:00; DocumentationCertificates: https://www.bimstore.co/products/ffas1321-609500bf0/document/product-certificates; DocumentationInstallationGuide: https://www.bimstore.co/products/ffas1321-609500bf0/document/installation-guide; DocumentationLiterature: https://www.bimstore.co/products/ffas1321-609500bf0/document/product-literature; DocumentationMaintenance: https://www.bimstore.co/products/ffas1321-609500bf0/document/maintenance-information; DocumentationTechnical: https://www.bimstore.co/products/ffas1321-609500bf0/document/technical-data-sheet; DurationUnit: Years; ExpectedLife: 0; Family Name: FFAS1321-609500BF0; Features: n/a; Finish: Chrome; Grade: n/a; ManufacturerName: American Standard; Material: Brass; ModelNumber: FFAS1321-609500BF0; ModelReference: Acacia Evolution Concealed Bath & Shower Mixer with U-box; ProductionYear: 2021; ReferencedStandard: GB 18145-2014; ReplacementCost: n/a; Shape: n/a; Size: 180 x 150 mm; TypeName: Acacia Evolution Concealed Bath & Shower Mixer with U-box; WarrantyDescription: n/a; WarrantyDurationLabor: 0; WarrantyDurationParts: 0; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.americanstandard-apac.com/; WarrantyGuarantorParts: https://www.americanstandard-apac.com/
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
